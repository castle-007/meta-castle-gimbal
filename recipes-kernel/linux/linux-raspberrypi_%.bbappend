FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://castle-gimbal.cfg"
